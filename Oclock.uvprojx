# Keil uVision project Oclock.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: SN32F407F SONiX
  pack: SONiX.SN32F4_DFP.1.1.1
  cpu: IRAM(0x20000000,0x2000) IROM(0x00000000,0x7FFC) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: exp1_LED_blink
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\Source\Driver;.\Source\Module
  memory RVCT4: ROM 0x0 size 0x7ffc
  memory RVCT9: RAM 0x20000000 size 0x2000
  group UserAPP
    ./Source/UserAPP/: main.c
  group Driver
    ./Source/Driver/: PFPA.c GPIO.c WDT.c Utility.c CT16B1.c I2C0.c
    E:/MCU_HANOI_CONTEST/src/Driver/: CT16B0.c CT16B0.h Utility.h SYS_con_drive.c SYS_con_drive.h SysTick.c SysTick.h ADC.c ADC.h CMP.c CMP.h CRC.c CRC.h CT16.h CT16B1.h CT16B5.c CT16B5.h DMA.c DMA.h Flash.c Flash.h
  group Module
    ./Source/Module/: KeyScan.c EEPROM.c Segment.c
    E:/MCU_HANOI_CONTEST/src/Module/: Buzzer.c Buzzer.h
  group Readme
    ./Source/Readme/: readme.txt
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.1
